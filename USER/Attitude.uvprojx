# Keil uVision project Attitude.uvprojx, settings and files
target Attitude (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HardWareDriver\HMC5883L;..\USER;..\IIC;..\HardWareDriver\IMU;..\HardWareDriver\Math;..\HardWareDriver\MPU6050;..\HardWareDriver\Service;..\HardWareDriver\UART1;..\HardWareDriver\USART_DMA;..\HardWareDriver\MS5611;..\HardWareDriver\Kalman;..\HardWareDriver\Copter;..\HardWareDriver\px4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../HardWareDriver/Copter/: copter_config.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARD_DRIVE
    ../HardWareDriver/HMC5883L/: HMC5883L.c
    ../HardWareDriver/IMU/: IMU.c Kalman_AHRS.c
    ../HardWareDriver/Math/: Fmath.c
    ../HardWareDriver/MPU6050/: MPU6050.c
    ../HardWareDriver/Service/: IOI2C.c my_printf.c Matrix.c
    ../HardWareDriver/MS5611/: ms5611.c
    ../HardWareDriver/Kalman/: Kalman.c
